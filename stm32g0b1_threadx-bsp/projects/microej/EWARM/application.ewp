# IAR project application.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32G0B1RE ST STM32G0B1RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: TX_INCLUDE_USER_DEFINE_FILE; USE_HAL_DRIVER; STM32G0B1xx; STM32_THREAD_SAFE_STRATEGY=2; TX_ENABLE_IAR_LIBRARY_SUPPORT
  ICCARM.CCIncludePath2: ..\..\..\sdk\x-cube-azrtos-g0\Drivers\CMSIS\RTOS2\Include; ..\main\inc; ../thirdparty; ..\..\..\sdk\STM32CubeG0\Drivers\STM32G0xx_HAL_Driver\Inc; ..\..\..\sdk\STM32CubeG0\Drivers\STM32G0xx_HAL_Driver\Inc\Legacy; ..\..\..\sdk\STM32CubeG0\Drivers\CMSIS\Device\ST\STM32G0xx\Include; ..\..\..\sdk\STM32CubeG0\Drivers\CMSIS\Include; ..\..\..\sdk\x-cube-azrtos-g0\Middlewares\ST\threadx\common\inc; ..\..\..\sdk\x-cube-azrtos-g0\Middlewares\ST\threadx\ports\cortex_m0\iar\inc; ..\..\..\sdk\x-cube-azrtos-g0\Middlewares\ST\threadx\utility\low_power; ..\core\inc; ..\platform\inc; ..\validation\tests\core\c\inc; ..\validation\port\inc; ..\validation\framework\c\utils\inc; ..\validation\framework\c\coremark; ..\platform\inc\intern
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: TX_LOW_POWER=1
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: stm32g0b1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cmsis
    ../../../sdk/x-cube-azrtos-g0/Middlewares/ST/cmsis_rtos_threadx/: cmsis_os2.c
  group microej/core
    ../core/src/: fault_handlers.c LLBSP_generic.c LLMJVM_ThreadX.c microej_main.c microej_time.c putchar.c
  group microej/main
    ../main/src/: gpio.c main.c stm32g0xx_hal_msp.c stm32g0xx_it.c tx_initialize_low_level.S
  group microej/platform/inc
    ../platform/inc/: BESTFIT_ALLOCATOR.h BESTFIT_ALLOCATOR_impl.h LLBSP_impl.h LLKERNEL_impl.h LLMJVM.h LLMJVM_impl.h LLMJVM_MONITOR_impl.h LLTRACE.h LLTRACE_impl.h MJVM_MONITOR.h MJVM_MONITOR_types.h sni.h
  group microej/platform/lib
    ../platform/lib/: microejapp.o microejruntime.a
  group sdk/STM32CubeG0/Drivers/CMSIS
    ../main/src/: system_stm32g0xx.c
  group sdk/STM32CubeG0/Drivers/STM32G0xx_HAL_Driver
    ../../../sdk/STM32CubeG0/Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_lptim.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c
  group sdk/STM32CubeG0/Middlewares/ThreadX/RTOS/ThreadX/Core
    ../../../sdk/x-cube-azrtos-g0/Middlewares/ST/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
    ../../../sdk/x-cube-azrtos-g0/Middlewares/ST/threadx/ports/cortex_m0/iar/src/: tx_iar.c tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group sdk/STM32CubeG0/Middlewares/ThreadX/RTOS/ThreadX/Low Power support
    ../../../sdk/x-cube-azrtos-g0/Middlewares/ST/threadx/utility/low_power/: tx_low_power.c
  group sdk/STM32CubeG0/Middlewares/ThreadX/RTOS/ThreadX/PerformanceInfo
    ../../../sdk/x-cube-azrtos-g0/Middlewares/ST/threadx/common/src/: tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c
  group sdk/STM32CubeG0/Middlewares/ThreadX/RTOS/ThreadX/TraceX support
    ../../../sdk/x-cube-azrtos-g0/Middlewares/ST/threadx/common/src/: tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c
  group startup
    ./: startup_stm32g0b1xx.s stm32g0b1xx_flash.icf
  group validation/coremark
    ../validation/framework/c/coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h
  group validation/port
    ../validation/port/src/: core_benchmark.c core_portme.c ram_checks.c time_base.c
    ../validation/framework/c/utils/src/: u_print.c u_time_base.c
  group validation/test
    ../validation/tests/core/c/src/: t_core_core_benchmark.c t_core_main.c t_core_print.c t_core_ram.c t_core_time_base.c x_impl_core_benchmark.c x_impl_ram_checks.c x_impl_ram_speed.c x_java_testsuite_impl.c x_ram_checks.c x_ram_speed.c
  group validation/utils
    ../validation/framework/c/embunit/embUnit/: AssertImpl.c RepeatedTest.c stdImpl.c TestCaller.c TestCase.c TestResult.c TestRunner.c TestSuite.c
